FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://logo.cfg \
            file://qt-lib32.cfg \
            file://0001-add-logo-bunch.patch \
            "

